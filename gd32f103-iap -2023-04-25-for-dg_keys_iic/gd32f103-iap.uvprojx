# Keil uVision project gd32f103-iap.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f103-iap +hex
  AfterMake: fromelf --bin -o ./output/@L.bin ./Objects/@L.axf
  AfterMake: cmd.exe /C copy output\@L.bin ..\jc_dg_keyboard_gd32mcu_freertos-2023-505-debug\temp\
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD
  c include: .\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/src/: common.c download.c main.c stm32f10x_it.c upload.c ymodem.c systick.c uart.c update_flag.c iic.c
software components: CMSIS:CORE 5.3.0, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
