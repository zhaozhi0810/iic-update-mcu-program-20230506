# Keil uVision project jc_dg_keyboard_gd32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: jc_dg_keyboard_gd32 +hex
  AfterMake: fromelf --bin -o ./temp/@L.bin ./Objects/@L.axf
  AfterMake: tools/combin temp/gd32f103-iap.bin temp/jc_dg_keyboard_gd32.bin output/gd32f103-iap_jc_dg_keyboard_gd32.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Application;.\freertos\include;.\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8005c00 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./Application/: gd32f103c_eval.c gpio.c main.c uart.c gd32f10x_it.c iic.c systick.c uart_debug_handle.c AT9236.c key_lights_flash.c ota-uart.c
  group freertos
    ./freertos/portable/MemMang/: heap_4.c
    ./freertos/portable/RVDS/ARM_CM3/: port.c
    ./freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
software components: CMSIS:CORE 5.3.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
